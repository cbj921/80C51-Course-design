# Keil uVision project project.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c buzzer.h delay.h digitalTube.h key.h led.h timer.h
